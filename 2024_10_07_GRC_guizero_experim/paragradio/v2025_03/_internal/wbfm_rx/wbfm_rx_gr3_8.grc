options:
  parameters:
    author: None
    generate_options: qt_gui
    id: wbfm_rx_gr3_8
    output_language: python
    title: wbfm_rx_gr3_8
  states: {}

blocks:
- name: bb_gain
  id: variable
  parameters:
    value: '32'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 97.3e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: hw_bb_filt
  id: variable
  parameters:
    value: '0'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-freq_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: freq_offset + channel_width/2
    low_cutoff_freq: freq_offset - channel_width/2
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 90e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: bb_gain
    bw0: hw_bb_filt
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: (2, 0, 1, 1)
    type: complex
    update_time: '0.03'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: (0, 0, 1, 1)
    name: '"Original Spectrum from device"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: (1, 0, 1, 1)
    name: '"After software filtering"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(48e3)
    taps: ''
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', analog_wfm_rcv_0, '0']
- [osmosdr_source_0, '0', band_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
