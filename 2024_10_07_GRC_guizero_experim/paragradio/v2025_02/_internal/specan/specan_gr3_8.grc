options:
  parameters:
    generate_options: qt_gui
    id: specan_gr3_8
    output_language: python
    title: specan_gr3_8
  states: {}

blocks:
- name: bb_gain
  id: variable
  parameters:
    value: '32'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 93e6
  states: {}
- name: hw_bb_filt
  id: variable
  parameters:
    value: 2.75e6
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: bb_gain
    bw0: hw_bb_filt
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: (1, 0, 1, 1)
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (0, 0, 1, 1)
    marker1: '0'
    marker2: '0'
    size: '100'
    srate: samp_rate
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: (2, 0, 1, 1)
    int_min: '-100'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
