options:
  parameters:
    generate_options: qt_gui
    id: psk_tx_loop_gr3_8
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: converted_constellationindex_from_modulation
  id: variable
  parameters:
    value: '["BPSK", "QPSK", "DQPSK", "8PSK", "16QAM"].index(modulation)'
  states: {}
- name: data
  id: variable
  parameters:
    value: '[0,0]'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: modulation
  id: variable
  parameters:
    value: '"BPSK"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: stel_16qam
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: stel_8psk
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {}
- name: stel_bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: stel_dqpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: dqpsk
  states: {}
- name: stel_qpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: complex(amplitude)
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: converted_constellationindex_from_modulation
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: data
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: data
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: data
  states: {}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: data
  states: {}
- name: blocks_vector_source_x_0_1_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: data
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: stel_bpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: stel_qpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: stel_dqpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_constellation_modulator_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: stel_8psk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_constellation_modulator_0_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: stel_16qam
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '0'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_source_x_0, '0', digital_constellation_modulator_0_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', digital_constellation_modulator_0_0_0_0_0, '0']
- [blocks_vector_source_x_0_1, '0', digital_constellation_modulator_0_0_0, '0']
- [blocks_vector_source_x_0_1_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_vector_source_x_0_1_0_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_selector_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_selector_0, '1']
- [digital_constellation_modulator_0_0_0, '0', blocks_selector_0, '2']
- [digital_constellation_modulator_0_0_0_0, '0', blocks_selector_0, '3']
- [digital_constellation_modulator_0_0_0_0_0, '0', blocks_selector_0, '4']

metadata:
  file_format: 1
