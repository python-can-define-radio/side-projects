options:
  parameters:
    generate_options: qt_gui
    id: bpsk_tx_loop_gr3_8
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: data
  id: variable
  parameters:
    value: np.array([0,0])
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: stel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: data
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: stel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '0'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
