options:
  parameters:
    generate_options: qt_gui
    id: wbfm_tx_microphone
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '50'
  states: {}
- name: osmocom_samp_rate
  id: variable
  parameters:
    value: audio_samp_rate*interp
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: osmocom_samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: osmocom_samp_rate
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '0'
    if_gain0: if_gain
    sample_rate: osmocom_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interp
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_tx_0, '0', osmosdr_sink_0, '0']
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
